# Keil uVision project TDT_Darts.uvprojx, settings and files
target Balance (6140000::V6.14::ARMCLANG)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Balance +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,USE_MAIN_CTRL_RM_CBOARD,SMALL_MODEL
  c misc: -frtti -Wno-invalid-source-encoding
  c include: C:\Users\sherlock\AppData\Local\Arm\Packs\ARM\CMSIS\5.9.0;..\ST_Lib\inc;..\User;..\DSP_Lib;..\TDT_Bsp\inc;..\TDT_Alg\inc;..\TDT_device\inc;..\TDT_Task\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.cpp board.cpp cycle.cpp stm32f4xx_it.c schedule.cpp
  group TDT_Task
    ../TDT_Task/src/: task_virtual.cpp imu_task.cpp led_task.cpp chassis_task.cpp lqrCtrl_task.cpp motion_task.cpp instableCheck_task.cpp mode_task.cpp
  group TDT_Alg
    ../TDT_Alg/src/: pid.cpp lqr.cpp crc.cpp filter.cpp imu.cpp ErrorTest.cpp my_math.cpp can_calculate.cpp AHRS_middleware.c AHRS.lib kalmanFilter.cpp angleTranseform.cpp
  group TDT_Bsp
    ../TDT_Bsp/src/: spi.cpp usart3.cpp can.cpp iwdg.cpp timer.cpp iic.cpp adc.cpp pwm.cpp
  group TDT_Device
    ../TDT_device/src/: dbus.cpp led.cpp motor.cpp mpu6050.cpp icm20602.cpp
    ../TDT_Device/src/: bmi088.cpp flash.cpp CyberGear.cpp beep.cpp
  group ST_Lib
    ../ST_Lib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c system_stm32f4xx.c
    ../ST_Lib/: startup_stm32f40_41xxx.s
  group DSP_Lib
    ../DSP_Lib/: arm_cortexM4lf_math.lib
